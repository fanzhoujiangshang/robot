# Keil uVision project Firmware_F427.uvprojx, settings and files
target Firmware (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware_F427 +hex
  AfterMake: fromelf --bin !L -o .\BIN\Firmware_F427_V10.bin
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: STM32F427_437xx,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --preinclude stm32f4xx_conf.h --diag_suppress=767
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\CONFIG\interface;..\HARDWARE\interface;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\COMMON\interface;..\COMMUNICATE\interface;..\EXP_MODULES\interface;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;..\MALLOC;..\CONTROL\interface;..\SENSORS\interface;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
    ./: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CONFIG
    ../CONFIG/src/: config_param.c
    ../CONFIG/interface/: config_param.h config.h FreeRTOSConfig.h stm32f4xx_conf.h
  group HARDWARE
    ../HARDWARE/src/: exti.c motors.c nvic.c uart_syslink.c system.c stmflash.c watchdog.c timer.c lan8720.c adc1.c leds.c mpu9250.c spi1.c MS5837.c i2c.c
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4x7_eth.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c filter.c maths.c
  group COMMUNICATE
    ../COMMUNICATE/src/: atkp.c comm.c console.c radiolink.c lanlink.c usblink.c
  group SENSORS
    ../SENSORS/src/: barometer.c imu.c accelerometer.c compass.c gyro.c sensorsalignment.c
  group CONTROL
    ../CONTROL/src/: kalman.c pm.c sensors.c stabilizer.c imu.c led_control.c motor_control.c
  group DSP_LIB
    ../DSP_Lib/: arm_common_tables.c arm_const_structs.c arm_cos_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mean_f32.c arm_sin_f32.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../USB/USB_APP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/tcp_server_demo/: tcp_server.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
